# Keil uVision project STM32H747I-DISCO.uvprojx, settings and files
target STM32H747I-DISCO_CM4 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32H747XIHx:CM4 STMicroelectronics
  cpu: IRAM(0x10000000-0x10047FFF) IRAM2(0x18000000-0x1800FFFF) IROM(0x8100000-0x81FFFFF) CLOCK(12000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32H747I-DISCO_CM4 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: CORE_CM4,USE_HAL_DRIVER,STM32H747xx
  c include: ../CM4/Core/Inc;  ../Drivers/STM32H7xx_HAL_Driver/Inc;  ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;  ../Drivers/CMSIS/Device/ST/STM32H7xx/Include;  ../Drivers/CMSIS/Include../CM7/Core/Inc;  ../Drivers/STM32H7xx_HAL_Driver/Inc;  ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;  ../Middlewares/Third_Party/FreeRTOS/Source/include;  ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;  ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;  ../Drivers/CMSIS/Device/ST/STM32H7xx/Include;  ../Drivers/CMSIS/Include
  asm include: ..\CM4\Core\Inc
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  memory RVCT10: RAM 0x18000000 size 0x10000
  scatter file: stm32h747xx_flash_CM4.sct
  group Application/MDK-ARM
    ./: startup_stm32h747xx_CM4.s startup_stm32h747xx_CM7.s
  group Application/User/CM7/TouchGFX/target
    ../CM7/TouchGFX/target/: STM32H7Instrumentation.cpp TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXGPIO.cpp
  group Application/User/CM7/TouchGFX/target/generated
    ../CM7/TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp OSWrappers.cpp
  group Application/User/CM7/TouchGFX/App
    ../CM7/TouchGFX/App/: app_touchgfx.c
  group Application/User/CM7/Core
    ../CM7/Core/Src/: main.c freertos.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Application/User/CM4/Core
    ../CM4/Core/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/otm8009a/: otm8009a.c otm8009a_reg.c
    ../Drivers/BSP/Components/ft6x06/: ft6x06.c ft6x06_reg.c
    ../Drivers/BSP/Components/mt25tl01g/: mt25tl01g.c
    ../Drivers/BSP/Components/is42s32800j/: is42s32800j.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dsi.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx_dualcore_boot_cm4_cm7.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Drivers/BSP/STM32H747I-Discovery
    ../Drivers/BSP/STM32H747I-Discovery/: stm32h747i_discovery_bus.c stm32h747i_discovery_qspi.c stm32h747i_discovery_sdram.c stm32h747i_discovery_ts.c
target STM32H747I-DISCO_CM7 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x00000000-0xFFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: STM32H747I-DISCO_CM7
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: CORE_CM7,USE_HAL_DRIVER,STM32H747xx
  c include: ../CM7/Core/Inc;  ../CM7/TouchGFX/App;  ../CM7/TouchGFX/target/generated;  ../CM7/TouchGFX/target;  ../Drivers/BSP/Components/Common;  ../Drivers/BSP/STM32H747I-Discovery;  ../Drivers/STM32H7xx_HAL_Driver/Inc;  ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;  ../Middlewares/Third_Party/FreeRTOS/Source/include;  ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;  ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;  ../Drivers/CMSIS/Device/ST/STM32H7xx/Include;  ../Drivers/CMSIS/Include../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;  ../Drivers/CMSIS/Include
  asm include: ..\CM7\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: stm32h747xx_flash_CM7.sct
software components: CMSIS:CORE 4.3.0
